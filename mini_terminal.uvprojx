# Keil uVision project mini_terminal.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: mini_terminal
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,USE_HSE_CRYSTAL,LV_CONF_INCLUDE_SIMPLE
  c misc: --diag_suppress=188,111,550
  c include: .\Main;.\Drivers\CMSIS;.\Drivers\Libs;.\Drivers\Peripherals;.\Libs\FreeRTOS\include;.\Libs\FreeRTOS\portable\RVDS\ARM_CM4F;.\Libs\LVGL;.\Libs\cJSON;.\App\Gui;.\App\Logic;.\App\Tasks
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Main
    ./Main/: main.c stm32f4xx_it.c
  group App/Gui
    ./App/Gui/: gui_menu.c gui_test.c gui_clock.c gui_page.c gui_sensor.c gui_api_demo.c gui_wifi.c gui_page.h
  group App/Logic
    ./App/Logic/: sensor_data.c net_data.c
  group App/Tasks
    ./App/Tasks/: task_init.c task_lvgl.c task_sensor.c task_wifi.c
  group Libs/cJSON
    ./Libs/cJSON/: cJSON.c
  group Libs/FreeRTOS
    ./Libs/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Libs/FreeRTOS/portable/MemMang/: heap_4.c
    ./Libs/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Libs/LVGL/Core
    ./Libs/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Libs/LVGL/Draw
    ./Libs/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./Libs/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group Libs/LVGL/Extra
    ./Libs/LVGL/src/extra/: lv_extra.c
    ./Libs/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ./Libs/LVGL/src/extra/themes/default/: lv_theme_default.c
    ./Libs/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ./Libs/LVGL/src/extra/layouts/flex/: lv_flex.c
    ./Libs/LVGL/src/extra/layouts/grid/: lv_grid.c
    ./Libs/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ./Libs/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./Libs/LVGL/src/extra/widgets/chart/: lv_chart.c
    ./Libs/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./Libs/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./Libs/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ./Libs/LVGL/src/extra/widgets/led/: lv_led.c
    ./Libs/LVGL/src/extra/widgets/list/: lv_list.c
    ./Libs/LVGL/src/extra/widgets/menu/: lv_menu.c
    ./Libs/LVGL/src/extra/widgets/meter/: lv_meter.c
    ./Libs/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ./Libs/LVGL/src/extra/widgets/span/: lv_span.c
    ./Libs/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ./Libs/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ./Libs/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ./Libs/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ./Libs/LVGL/src/extra/widgets/win/: lv_win.c
  group Libs/LVGL/Font
    ./Libs/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Libs/LVGL/Hal
    ./Libs/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Libs/LVGL/Misc
    ./Libs/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Libs/LVGL/Widgets
    ./Libs/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Port
    ./Port/: bsp_init.c lvgl_prot_disp.c lvgl_port_indev.c
  group Drivers/CMSIS
    ./Drivers/CMSIS/: core_cm4.h startup_stm32f411xe.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group Drivers/Peripherals
    ./Drivers/Peripherals/: SPI.c ST7735s.c Utils.c EC11.c I2C.c Sensors.c ESP01S.c GL.c USART2.c
  group Drivers/Libs
    ./Drivers/Libs/: misc.c stm32f4xx_adc.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
software components: CMSIS:CORE 5.0.2
